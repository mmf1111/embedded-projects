# Keil uVision project pcf8591.uvproj, settings and files
target IK-STC15 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: pcf8591 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User;..\Source
  group USER
    ../User/: main.c
  group SOURCE
    ../Source/: delay.c led.c i2c_hw.c keyboard.c pcf8591.c timer.c ledseg.c delay.h ds18b20.c ds18b20.h i2c_hw.h keyboard.h led.h ledseg.h pcf8591.h timer.h
  group DOC
    ../Doc/: 实验说明.txt
